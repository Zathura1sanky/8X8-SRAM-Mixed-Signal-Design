* E:\FOSSEE\eSim\library\SubcircuitLibrary\SANKET_8X8_BIT_ADDRESSABLE_RAM\SANKET_8X8_BIT_ADDRESSABLE_RAM.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/07/22 19:21:26

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X1  Net-_U1-Pad1_ Net-_U1-Pad26_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ SANKET_SRAM_BIT_ADDRESSABLE
X2  Net-_U1-Pad5_ Net-_U1-Pad26_ Net-_U1-Pad6_ Net-_U1-Pad3_ Net-_U1-Pad7_ SANKET_SRAM_BIT_ADDRESSABLE
X3  Net-_U1-Pad8_ Net-_U1-Pad26_ Net-_U1-Pad9_ Net-_U1-Pad3_ Net-_U1-Pad10_ SANKET_SRAM_BIT_ADDRESSABLE
X4  Net-_U1-Pad11_ Net-_U1-Pad26_ Net-_U1-Pad12_ Net-_U1-Pad3_ Net-_U1-Pad13_ SANKET_SRAM_BIT_ADDRESSABLE
X5  Net-_U1-Pad14_ Net-_U1-Pad26_ Net-_U1-Pad15_ Net-_U1-Pad3_ Net-_U1-Pad16_ SANKET_SRAM_BIT_ADDRESSABLE
X6  Net-_U1-Pad17_ Net-_U1-Pad26_ Net-_U1-Pad18_ Net-_U1-Pad3_ Net-_U1-Pad19_ SANKET_SRAM_BIT_ADDRESSABLE
X7  Net-_U1-Pad20_ Net-_U1-Pad26_ Net-_U1-Pad21_ Net-_U1-Pad3_ Net-_U1-Pad22_ SANKET_SRAM_BIT_ADDRESSABLE
X8  Net-_U1-Pad23_ Net-_U1-Pad26_ Net-_U1-Pad24_ Net-_U1-Pad3_ Net-_U1-Pad25_ SANKET_SRAM_BIT_ADDRESSABLE
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ Net-_U1-Pad24_ Net-_U1-Pad25_ Net-_U1-Pad26_ PORT

.end
